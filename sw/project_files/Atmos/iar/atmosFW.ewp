# IAR project atmosFW.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F091RC ST STM32F091RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\..\..\common\tym_qp_lib; ..\..\..\common\qp\include; ..\..\..\common\qp\ports\stm32; ..\..\..\common\include; ..\..\..\driver\include; ..\stm32\include; ..\..\..\server\include; ..\..\..\hardware_management\include; ..\..\..\bsp\STM32\Libraries\CMSIS\Include; ..\..\..\bsp\STM32\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\bsp\STM32\Libraries\CMSIS\ST\STM32F0xx\Include; ..\..\..\bsp\STM32\include; ..\; ..\DSP; ..\..\..\include; ..\conf; ..\..\..\bootloaders\bl_stm32\inc; ..\Atmos_App\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ATMOS_fw.hex
  ILINK.IlinkOutputFile: atmosFW.out
  ILINK.IlinkIcfFile: atmosFW.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F0XX
  ICCARM.CCIncludePath2: ..\..\..\common\tym_qp_lib; ..\..\..\common\qp\include; ..\..\..\common\qp\ports\stm32; ..\..\..\common\include; ..\..\..\driver\include; ..\stm32\include; ..\..\..\server\include; ..\..\..\hardware_management\include; ..\..\..\bsp\STM32\Libraries\CMSIS\Include; ..\..\..\bsp\STM32\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\bsp\STM32\Libraries\CMSIS\ST\STM32F0xx\Include; ..\..\..\bsp\STM32\STM32F0-Discovery; ..\..\..\bsp\STM32\include; ..\; ..\DSP; ..\..\..\include; ..\conf; ..\mainApp; ..\..\..\server\ase_tk_server\message_format; ..\audio_ADC; ..\..\..\ui_layer\BnO_MainApp\inc; ..\mainApp; ..\..\..\bootloaders\bl_stm32\inc; ..\amp
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: atmos_fw.hex
  group Atmos/mainApp
    ../Atmos_App/: main.c MainApp.c MainApp_commEvtHandler.c MainApp_keyEvtHandler.c MainApp_tickEvtHandler.c MainApp_util.c
  group Atmos/stm32
    ../stm32/: attachedDevices.c projBsp.c
  group Atmos/ui_layer/application
    ../../../ui_layer/application/: application.c
  group Atmos/ui_layer/delegate
    ../../../ui_layer/delegate/: delegate.c
  group Atmos/ui_layer/delegate/idle_dlg
    ../../../ui_layer/delegate/idle_dlg/: IdleDlg.c
  group bsp
    ../../../bsp/stm32/: bsp.c
  group common
    ../../../bootloaders/bl_stm32/: bl_common.c
    ../../../common/controller/: controller.c
    ../../../common/crc16_lib/: crc16.c
    ../../../common/: persistantObj.c seq.c
    ../../../common/pt_lib/: pt_tp.c
    ../../../common/datatype/ringbuf/: ringbuf.c
    ../../../common/sort_lib/: sortLib.c
    ../../../common/timer_lib/: timer.c
    ../../../common/tym_qp_lib/: tym_qp_lib.c
  group config
    ../conf/: AudioDrv.config AudioSrv.Config CommSrv.Config controller.Config IoExpanderDrv.config KeySrv.Config LedSrv.Config PowerDrv_light.config SettingSrv.config
    ../: product.config
  group driver/adc_driver
    ../../../driver/adc_driver/stm32/: AdcDrv.c
  group driver/Audio_driver
    ../portingLayer/AudioPorting/: AudioDrv.c
    ../../../driver/audio_driver/pcm9211/: Pcm9211_Drv.c
  group driver/Audio_driver/Amplifier
    ../../../driver/audio_driver/Ssm3582/: Ssm3582_Drv.c
  group driver/Audio_driver/HDMI_EP91A6S
    ../../../driver/hdmi_driver/EP91A6S/: HdmiDrv.c
  group driver/comm_driver
    ../../../driver/comm_driver/: CommDrv.c
  group driver/dsp_driver
    ../DSP/: adsp21584_config.h
    ../../../driver/DSP_Driver/adsp21584_drv/: adsp21584Drv.c
  group driver/gpio_driver
    ../../../driver/gpio_driver/stm32/: GpioDrv.c
  group driver/i2c_driver
    ../../../driver/i2c_driver/stm32f0/: I2CDrv.c
  group driver/ioexpander_driver
    ../../../driver/ioexpander_driver/: IoExpanderDrv.c
  group driver/key_driver
    ../../../driver/key_driver/: AdcKeyDrv.c GpioKeyDrv.c KeyDrv.c
  group driver/led_driver
    ../../../driver/led_driver/: IoExpanderLedDrv.c LedDrv.c
  group driver/spi_driver
    ../../../driver/spi_driver/stm32f0/: SpiDrv.c
  group driver/stm32_driver/startUpCode
    ../../../bsp/stm32/Libraries/CMSIS/ST/STM32F0xx/Source/: startup_stm32f0xx.s
  group driver/stm32_driver/STM32F0xx_StdPeriph_Driver
    ../../../bsp/stm32/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_dbgmcu.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_usart.c
  group driver/storage_driver
    ../../../driver/storage_driver/stm32/: NvmDrv.c
    ../../../driver/storage_driver/: StorageDrv.c
  group driver/SWi2c_driver
    ../../../driver/SWi2c_driver/stm32f0/: SWi2c_Drv.c
  group driver/uart_drvier
    ../../../common/framing/yahdlc/C/: fcs16.c yahdlc.c
    ../../../common/nanopb/: pb_common.c pb_decode.c pb_encode.c
    ../../../driver/uart_driver/stm32/: UartDrv.c
  group hardware_managerment
    ../../../hardware_management/: deviceTypes.c
  group QP/qep
    ../../../common/qp/qep/source/: qep.c qep_pkg.h qfsm_dis.c qfsm_ini.c qhsm_dis.c qhsm_in.c qhsm_ini.c qhsm_top.c qmsm_dis.c qmsm_ini.c
  group QP/qf
    ../../../common/qp/qf/source/: qa_ctor.c qa_defer.c qa_fifo.c qa_get_.c qa_lifo.c qa_sub.c qa_usub.c qa_usuba.c qeq_fifo.c qeq_get.c qeq_init.c qeq_lifo.c qf_act.c qf_gc.c qf_log2.c qf_new.c qf_pkg.h qf_pool.c qf_psini.c qf_pspub.c qf_pwr2.c qf_tick.c qma_ctor.c qmp_get.c qmp_init.c qmp_put.c qte_arm.c qte_ctor.c qte_ctr.c qte_darm.c qte_rarm.c qvanilla.c
  group QP/qp_port
    ../../../common/qp/ports/stm32/: qep_port.h qf_port.h qs_port.h
  group server
    ../../../server/: server.c
  group server/audio_server
    ../../../server/audio_server/audioSrv_new/: AudioSrv.c
  group server/comm_server
    ../../../server/comm_server/: CommSrv.c
  group server/debug_server
    ../../../server/tp_debug_server/: cli.c cli_pt_cmd.c cli_version_cmd.c DebugSrv.c
  group server/key_server
    ../../../server/key_server/: KeySrv.c
  group server/led_server
    ../../../server/led_server/: LedSrv.c LedSrv_group.c
  group server/setting_server
    ../../../server/setting_server/: SettingSrv.c

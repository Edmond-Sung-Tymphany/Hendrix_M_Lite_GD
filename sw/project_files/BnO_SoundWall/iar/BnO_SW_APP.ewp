# IAR project BnO_SW_APP.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072CB ST STM32F072CB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\..\..\common\qp\include; ..\..\..\common\qp\ports\stm32; ..\..\..\driver\include; ..\stm32\include; ..\..\..\server\include; ..\..\..\ui_layer\include; ..\..\..\hardware_management\include; ..\..\..\bsp\stm32\Libraries\CMSIS\Include; ..\..\..\bsp\stm32\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\bsp\stm32\Libraries\CMSIS\ST\STM32F0xx\Include; ..\..\..\bsp\stm32\include; ..\DSP; ..\..\..\include; ..\..\..\common\tym_qp_lib; ..\conf; ..; ..\..\..\server\usb_server; ..\..\..\driver\usb_driver\stm32f0\class\vcp\inc; ..\..\..\driver\usb_driver\stm32f0\core\inc; ..\..\..\driver\usb_driver\stm32f0; ..\include; ..\..\..\common\nanopb; ..\..\..\common\framing\yahdlc\C; ..\portingLayer\include; ..\protobuf\ASE_code
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BnO_SW_APP.hex
  ILINK.IlinkOutputFile: BnO_SW_APP.out
  ILINK.IlinkIcfFile: BnO_SW_APP.icf
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX; NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\common\qp\include; ..\..\..\common\qp\ports\stm32; ..\..\..\driver\include; ..\stm32\include; ..\..\..\server\include; ..\..\..\ui_layer\include; ..\..\..\hardware_management\include; ..\..\..\bsp\stm32\Libraries\CMSIS\Include; ..\..\..\bsp\stm32\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\bsp\stm32\Libraries\CMSIS\ST\STM32F0xx\Include; ..\..\..\bsp\stm32\include; ..\..\..\include; ..\conf; ..\..\..\common\tym_qp_lib; ..\..\..\driver\usb_driver; ..\..\..\driver\usb_driver\stm32f0\class\vcp\inc; ..\..\..\driver\usb_driver\stm32f0\core\inc; ..\..\..\server\usb_server; ..\include; ..
  group common
    ../../../bsp/stm32/: bsp.c
    ../../../common/controller/: controller.c
    ../../../common/crc16_lib/: crc16.c
    ../../../common/framing/yahdlc/C/: fcs16.c yahdlc.c
    ../../../common/nanopb/: pb_common.c pb_decode.c pb_encode.c
    ../../../common/: persistantObj.c
    ../../../common/datatype/ringbuf/: ringbuf.c
    ../../../common/sort_lib/: sortLib.c
  group driver/a2b_driver
    ../../../driver/a2b_driver/: adi_ad24xx.c
  group driver/adc_driver
    ../../../driver/adc_driver/stm32/: AdcDrv.c
  group driver/audio_driver
    ../portingLayer/AudioPorting/: AudioDrv.c
  group driver/codec_driver
    ../portingLayer/CS42528Drv/: Codec_cs42528.c
  group driver/dsp_driver
    ../portingLayer/Adau1452_drv/: Adau1452_Drv.c
  group driver/gpio_driver
    ../../../driver/gpio_driver/stm32/: GpioDrv.c
  group driver/i2c_driver
    ../../../driver/i2c_driver/stm32f0/: I2CDrv.c
  group driver/i2cSlave_driver
    ../portingLayer/I2cSlaveDrv/: I2cSlaveDrv.c
  group driver/IoeLed_driver
    ../portingLayer/IoeLedDrv/: IoeLedDrv.c
  group driver/periodic_driver
    ../portingLayer/PeriodicTask/: PeriodicTask.c
  group driver/stm32_driver/startUpCode
    ../../../bsp/stm32/Libraries/CMSIS/ST/STM32F0xx/Source/: startup_stm32f0xx.s
  group driver/stm32_driver/STM32F0xx_StdPeriph_Driver
    ../../../bsp/stm32/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_crs.c stm32f0xx_dbgmcu.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
  group driver/storage_driver
    ../../../driver/storage_driver/stm32/: NvmDrv.c
    ../../../driver/storage_driver/: StorageDrv.c
  group driver/SWi2c_driver
    ../../../driver/SWi2c_driver/stm32f0/: SWi2c_Drv.c
  group driver/system_driver
    ../portingLayer/SystemDrv/: SystemDrv_SoundWall.c
  group driver/uart_drvier
    ../../../driver/uart_driver/stm32/: UartDrv.c
  group driver/usb_driver
    ../../../driver/usb_driver/stm32f0/: UsbDrv.c UsbDrv_priv.h
  group driver/usb_driver/class/vcp
    ../../../driver/usb_driver/stm32f0/class/vcp/src/: usb_bsp.c usbd_cdc_core.c usbd_cdc_vcp.c usbd_desc.c usbd_pwr.c
  group driver/usb_driver/core
    ../../../driver/usb_driver/stm32f0/core/src/: usb_core.c usb_dcd.c usb_dcd_int.c usbd_core.c usbd_ioreq.c usbd_req.c
  group hardware_managerment
    ../../../hardware_management/: deviceTypes.c
  group QP/qep
    ../../../common/qp/qep/source/: qep.c qep_pkg.h qfsm_dis.c qfsm_ini.c qhsm_dis.c qhsm_in.c qhsm_ini.c qhsm_top.c qmsm_dis.c qmsm_ini.c
  group QP/qf
    ../../../common/qp/qf/source/: qa_ctor.c qa_defer.c qa_fifo.c qa_get_.c qa_lifo.c qa_sub.c qa_usub.c qa_usuba.c qeq_fifo.c qeq_get.c qeq_init.c qeq_lifo.c qf_act.c qf_gc.c qf_log2.c qf_new.c qf_pkg.h qf_pool.c qf_psini.c qf_pspub.c qf_pwr2.c qf_tick.c qma_ctor.c qmp_get.c qmp_init.c qmp_put.c qte_arm.c qte_ctor.c qte_ctr.c qte_darm.c qte_rarm.c qvanilla.c
  group QP/qp_port
    ../../../common/qp/ports/stm32/: qep_port.h qf_port.h qs_port.h
  group QP/tym_qp_lib
    ../../../common/tym_qp_lib/: tym_qp_lib.c
  group server/a2b_server
    ../../../server/a2b_server/: a2bSrv.c
  group server/audio_server
    ../../../server/audio_server/audioSrv_new/: AudioSrv.c
  group server/ds_server
    ../../../server/ds_server/: DebugSSrv.c
  group server/i2cSlave_server
    ../../../server/i2c_server/: I2cSrv.c
  group server/periodic_server
    ../../../server/periodic_server/: PeriodicSrv.c
  group server/setting_server
    ../../../server/setting_server/: SettingSrv.c
  group server/system_server
    ../../../server/system_server/: SystemSrv.c
  group server/usb_server
    ../../../server/usb_server/: UsbSrv.c UsbSrv_priv.h
  group SoundWall
    ../stm32/: attachedDevices.c projBsp.c
    ../MainApp/: main.c MainApp.c
  group SoundWall/protobuf
    ../protobuf/ASE_code/: ase-fep-ReqResp.pb.c ase-fep.pb.c common.pb.c core.pb.c dsp.pb.c eeb.pb.c fep-ase-ReqResp.pb.c fep-ase.pb.c firmware-update.pb.c hdmi.pb.c light-sensor.pb.c player.pb.c power-link.pb.c production.pb.c puc.pb.c soundwall.pb.c spdif.pb.c system.pb.c wpl.pb.c

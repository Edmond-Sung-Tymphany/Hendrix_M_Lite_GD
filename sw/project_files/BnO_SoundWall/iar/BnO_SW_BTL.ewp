# IAR project BnO_SW_BTL.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072RB ST STM32F072RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F0XX; USE_STDPERIPH_DRIVER; BOOTLOADER_MACROS; UART_DRV_BLOCKING
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\..\..\common\tym_qp_lib; ..\..\..\common\qp\include; ..\..\..\common\qp\ports\stm32; ..\..\..\common\include; ..\..\..\driver\include; ..\stm32\include; ..\..\..\hardware_management\include; ..\..\..\bsp\STM32\Libraries\CMSIS\Include; ..\..\..\bsp\STM32\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\bsp\STM32\Libraries\CMSIS\ST\STM32F0xx\Include; ..\..\..\bsp\STM32\STM32F0-Discovery; ..\..\..\bsp\STM32\include; ..\; ..\..\..\include; ..; ..\include; ..\portingLayer\include; ..\conf
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BnO_SW_BTL.hex
  ILINK.IlinkOutputFile: BnO_SW_BTL.out
  ILINK.IlinkIcfFile: BnO_SW_BTL.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F0XX; BOOTLOADER_MACROS; UART_DRV_BLOCKING
  ICCARM.CCIncludePath2: ..\..\..\common\tym_qp_lib; ..\..\..\common\qp\include; ..\..\..\common\qp\ports\stm32; ..\..\..\common\include; ..\..\..\driver\include; ..\stm32\include; ..\..\..\hardware_management\include; ..\..\..\bsp\STM32\Libraries\CMSIS\Include; ..\..\..\bsp\STM32\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\bsp\STM32\Libraries\CMSIS\ST\STM32F0xx\Include; ..\..\..\bsp\STM32\STM32F0-Discovery; ..\..\..\bsp\STM32\include; ..\..\..\include; ..\stm32\bootloader; ..; ..\include; ..\conf
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: BnO_SW_BL.hex
  ILINK.IlinkOutputFile: BnO_SW_BL.out
  group BootLoader
    ../stm32/: attachedDevices.c
    ../BootLoader/: BootLoader.c BootLoader_bsp.c BootLoader_common.c
  group driver
    ../../../hardware_management/: deviceTypes.c
  group driver/gpio
    ../../../driver/gpio_driver/stm32/: GpioDrv.c
  group driver/I2C
    ../../../driver/i2c_driver/stm32f0/: I2CDrv.c
  group driver/Led
    ../portingLayer/IoeLedDrv/: IoeLedDrv.c
  group driver/SWi2c
    ../../../driver/SWi2c_driver/stm32f0/: SWi2c_Drv.c
  group driver/system
    ../portingLayer/SystemDrv/: SystemDrv_BTL.c
  group driver/uart
    ../../../common/datatype/ringbuf/: ringbuf.c
    ../../../driver/uart_driver/stm32/: UartDrv.c
  group header
    ../stm32/include/: attachedDevices.h
    ../../../include/: commonTypes.h
    ../../../hardware_management/include/: deviceTypes.h
    ../: product.config
  group stm32xx
    ../../../bsp/stm32/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_crc.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_usart.c
    ../../../bsp/stm32/Libraries/CMSIS/ST/STM32F0xx/Source/: system_stm32f0xx.c

<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\BnO_SW_BTL.ewp</path>
  </project>
  <batchBuild/>
</workspace>



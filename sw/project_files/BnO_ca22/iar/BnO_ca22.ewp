# IAR project BnO_ca22.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F091RC ST STM32F091RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX; ca22
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\..\..\common\tym_qp_lib; ..\..\..\common\qp\include; ..\..\..\common\qp\ports\stm32; ..\..\..\common\include; ..\..\..\driver\include; ..\stm32\include; ..\..\..\server\include; ..\..\..\hardware_management\include; ..\..\..\bsp\STM32\Libraries\CMSIS\Include; ..\..\..\bsp\STM32\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\bsp\STM32\Libraries\CMSIS\ST\STM32F0xx\Include; ..\..\..\bsp\STM32\STM32F0-Discovery; ..\..\..\bsp\STM32\include; ..\; ..\DSP; ..\..\..\include; ..\conf; ..\mainApp; ..\..\..\ui_layer\BnO_MainApp\inc; ..\mainApp; ..\..\..\bootloaders\bl_stm32\inc; ..\amp; ..\..\..\server\ase_ng_server\ase_ng_proto_compiled; ..\..\..\ui_layer\include; ..\DSP; ..\portingLayer\adau1452_Drv; ..\portingLayer\include; ..\portingLayer\hdmiPorting; ..\portingLayer\pcm1862
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BnO_ca22.hex
  ILINK.IlinkOutputFile: app.out
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkIcfFile: BnO_ca22.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX; ca22; NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\common\tym_qp_lib; ..\..\..\common\qp\include; ..\..\..\common\qp\ports\stm32; ..\..\..\common\include; ..\..\..\driver\include; ..\stm32\include; ..\..\..\server\include; ..\..\..\hardware_management\include; ..\..\..\bsp\STM32\Libraries\CMSIS\Include; ..\..\..\bsp\STM32\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\bsp\STM32\Libraries\CMSIS\ST\STM32F0xx\Include; ..\..\..\bsp\STM32\STM32F0-Discovery; ..\..\..\bsp\STM32\include; ..\; ..\DSP; ..\..\..\include; ..\conf; ..\mainApp; ..\..\..\ui_layer\BnO_MainApp\inc; ..\mainApp; ..\..\..\bootloaders\bl_stm32\inc; ..\amp; ..\..\..\server\ase_ng_server\ase_ng_proto_compiled; ..\..\..\ui_layer\include; ..\DSP; ..\portingLayer\adau1452_Drv; ..\portingLayer\hdmiPorting; ..\portingLayer\include; ..\portingLayer\pcm1862
  ICCARM.CCOptLevel: 3
  group bsp
    ../../../bsp/stm32/: bsp.c
  group ca22/mainApp
    ../mainApp/: MainApp.c MainApp_aseTkEvtHandler.c MainApp_aseTkEvtHandler.h MainApp_keyEvtHandler.c MainApp_keyEvtHandler.h MainApp_tickEvtHandler.c MainApp_tickEvtHandler.h MainApp_util.c MainApp_util.h
  group ca22/stm32
    ../stm32/: attachedDevices.c projBsp.c
  group common
    ../../../bootloaders/bl_stm32/: bl_common.c
    ../../../common/controller/: controller.c
    ../../../common/crc16_lib/: crc16.c
    ../../../common/: persistantObj.c seq.c
    ../../../common/datatype/ringbuf/: ringbuf.c
    ../../../common/sort_lib/: sortLib.c
    ../../../common/timer_lib/: timer.c
    ../../../common/tym_qp_lib/: tym_qp_lib.c
  group config
    ../conf/: AudioDrv.config AudioSrv.Config controller.Config IoExpanderDrv.config KeySrv.Config LedSrv.Config PowerDrv_light.config SettingSrv.config
    ../: product.config
  group driver/adc_driver
    ../../../driver/adc_driver/stm32/: AdcDrv.c
  group driver/Audio_driver
    ../portingLayer/AudioPorting/: AudioDrv.c
  group driver/dsp_driver
    ../portingLayer/adau1452_Drv/: Adau1452_Drv.c
    ../../../driver/DSP_Driver/adsp21584_drv/: adsp21584Drv.c
    ../portingLayer/CS48L11Drv/: CS48L11_Driver.c
    ../portingLayer/Cs8422Drv/: Cs8422_Driver.c
    ../portingLayer/Pcm1690Drv/: Pcm1690_Driver.c
    ../../../driver/audio_driver/pcm1862_swi2c/: pcm1862Drv_swi2c.c
  group driver/gpio_driver
    ../../../driver/gpio_driver/stm32/: GpioDrv.c
  group driver/hdmi_driver
    ../portingLayer/hdmiPorting/: HdmiDrv.c HdmiDrv.h HdmiDrv_priv.h
  group driver/HWspi_driver
    ../../../driver/HWspi_driver/stm32f0/: HWspiDrv.c
  group driver/i2c_driver
    ../../../driver/i2c_driver/stm32f0/: I2CDrv.c
  group driver/ioexpander_driver
    ../../../driver/ioexpander_driver/: IoExpanderDrv_9110b.c IoExpanderDrv_9120.c IoExpanderDrv_9523.c
  group driver/key_driver
    ../../../driver/key_driver/: AdcKeyDrv.c GpioKeyDrv.c KeyDrv.c
  group driver/led_driver
    ../../../driver/led_driver/: IoExpanderLedDrv.c LedDrv.c LedStripGoogleDrv.c
  group driver/power_driver
    ../portingLayer/PowerPorting/: PowerDrv_light.c
  group driver/stm32_driver/startUpCode
    ../../../bsp/stm32/Libraries/CMSIS/ST/STM32F0xx/Source/: startup_stm32f0xx.s
  group driver/stm32_driver/STM32F0xx_StdPeriph_Driver
    ../../../bsp/stm32/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_dbgmcu.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_usart.c
  group driver/storage_driver
    ../../../driver/storage_driver/stm32/: NvmDrv.c
    ../../../driver/storage_driver/: StorageDrv.c
  group driver/SWi2c_driver
    ../../../driver/SWi2c_driver/stm32f0/: SWi2c_Drv.c
  group driver/uart_drvier
    ../../../common/framing/yahdlc/C/: fcs16.c yahdlc.c
    ../../../common/nanopb/: pb_common.c pb_decode.c pb_encode.c
    ../../../driver/uart_driver/stm32/: UartDrv.c
  group hardware_managerment
    ../../../hardware_management/: deviceTypes.c
  group QP/qep
    ../../../common/qp/qep/source/: qep.c qep_pkg.h qfsm_dis.c qfsm_ini.c qhsm_dis.c qhsm_in.c qhsm_ini.c qhsm_top.c qmsm_dis.c qmsm_ini.c
  group QP/qf
    ../../../common/qp/qf/source/: qa_ctor.c qa_defer.c qa_fifo.c qa_get_.c qa_lifo.c qa_sub.c qa_usub.c qa_usuba.c qeq_fifo.c qeq_get.c qeq_init.c qeq_lifo.c qf_act.c qf_gc.c qf_log2.c qf_new.c qf_pkg.h qf_pool.c qf_psini.c qf_pspub.c qf_pwr2.c qf_tick.c qma_ctor.c qmp_get.c qmp_init.c qmp_put.c qte_arm.c qte_ctor.c qte_ctr.c qte_darm.c qte_rarm.c qvanilla.c
  group QP/qp_port
    ../../../common/qp/ports/stm32/: qep_port.h qf_port.h qs_port.h
  group server
    ../../../server/: server.c
  group server/aseng_server
    ../../../server/ase_ng_server/ase_ng_proto_compiled/: ase-fep-ReqResp.pb.c ase-fep-ReqResp.pb.h ase-fep.pb.c ase-fep.pb.h common.pb.c common.pb.h core.pb.c core.pb.h dsp.pb.c dsp.pb.h eeb.pb.c eeb.pb.h fep-ase-ReqResp.pb.c fep-ase-ReqResp.pb.h fep-ase.pb.c fep-ase.pb.h firmware-update.pb.c firmware-update.pb.h hdmi.pb.c hdmi.pb.h light-sensor.pb.c light-sensor.pb.h player.pb.c player.pb.h power-link.pb.c power-link.pb.h production.pb.c production.pb.h puc.pb.c puc.pb.h soundwall.pb.c soundwall.pb.h spdif.pb.c spdif.pb.h system.pb.c system.pb.h wpl.pb.c wpl.pb.h
    ../../../server/ase_ng_server/: AseNgSrv.c AseNgSrv_priv.h
  group server/audio_server
    ../../../server/audio_server/audioSrv_new/: AudioSrv.c
  group server/debug_server
    ../../../server/ds_server/: DebugSSrv.c
  group server/hdmi_server
    ../portingLayer/hdmiPorting/: HdmiSrv.c
  group server/key_server
    ../../../server/key_server/: KeySrv.c
  group server/led_server
    ../../../server/led_server/: LedSrv.c
  group server/power_server
    ../../../server/power_server/powerSrv_new/: PowerSrv.c
  group server/setting_server
    ../../../server/setting_server/: SettingSrv.c
  group ui_layer/main
    ../../../ui_layer/BnO_MainApp/src/: main.c

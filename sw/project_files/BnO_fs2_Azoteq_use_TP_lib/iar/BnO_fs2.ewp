# IAR project BnO_fs2.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F091RC ST STM32F091RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX; BnO_fs2
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\..\..\common\qp\include; ..\..\..\common\qp\ports\stm32; ..\..\..\driver\include; ..\..\..\project_files\BnO_fs2\stm32\include; ..\..\..\server\include; ..\..\..\hardware_management\include; ..\..\..\bsp\STM32\Libraries\CMSIS\Include; ..\..\..\bsp\STM32\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\bsp\STM32\Libraries\CMSIS\ST\STM32F0xx\Include; ..\..\..\bsp\STM32\include; ..\..\..\project_files\BnO_fs2\; ..\..\..\include; ..\..\..\ui_layer\BnO_MainApp\inc; ..\..\..\driver\key_driver\AzIntegTouchKeyDrv\inc; ..\..\..\project_files\BnO_fs2\conf
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BnO_fs2.hex
  ILINK.IlinkOutputFile: BnO_fs2.out
  ILINK.IlinkAdditionalLibs: ..\Lib\BnO_fs2.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F0XX; Q_NASSERT; BnO_fs2
  ICCARM.CCOptLevel: 3
  group driver/i2c_driver
    ../../../driver/i2c_driver/stm32f0/: I2CDrv.c
  group driver/key_driver/AzIntegTouchKeyDrv
    ../../../driver/key_driver/: AzIntegTouchKeyDrv.c
  group driver/key_driver/AzIntegTouchKeyDrv/inc
    ../../../driver/key_driver/AzIntegTouchKeyDrv/inc/: Defines.h Gestures.h I2C_Comms.h IQS333.h IQS333_Init.h IQS5xx.h IQS5xx_HEX_Array.h IQS_Commands.h State_Machine.h
  group driver/key_driver/AzIntegTouchKeyDrv/src
    ../../../driver/key_driver/AzIntegTouchKeyDrv/src/: Gestures.c I2C_Comms.c IQS333.c IQS5xx.c IQS_Commands.c State_Machine.c
  group ui_layer/BnO_MainApp
    ../../../ui_layer/BnO_MainApp/src/: main.c

# IAR project Backup (2) of Hendrix_M.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F130x8 GD GD32F130x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\..\..\common\qp\include; ..\..\..\common\qp\ports\stm32; ..\..\..\common\include; ..\..\..\driver\include; ..\gd32\include; ..\..\..\server\include; ..\..\..\hardware_management\include; ..\..\..\bsp\gd32\Libraries\CMSIS\Include; ..\..\..\bsp\gd32\Libraries\GD32F35x_StdPeriph_Driver\inc; ..\..\..\bsp\gd32\Libraries\CMSIS\GD\STM32F0xx\Include; ..\..\..\bsp\gd32\include; ..\; ..\DSP; ..\..\..\include; ..\conf; ..\..\..\common\tym_qp_lib; ..\include; ..\mainApp; ..\portingLayer\PowerDrv; ..\..\..\bsp\gd32\STM32F0-Discovery; D:\projects_ben\tymphany_platform\sw\ui_layer\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Hendrix_M.hex
  ILINK.IlinkOutputFile: Hendrix_M.out
  ILINK.IlinkIcfFile: Hendrix.icf
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F030R8 ST STM32F030R8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F0XX; Q_NASSERT
  ICCARM.CCIncludePath2: ..\..\..\common\qp\include; ..\..\..\common\qp\ports\stm32; ..\..\..\common\include; ..\..\..\driver\include; ..\stm32\include; ..\..\..\server\include; ..\..\..\ui_layer\include; ..\..\..\hardware_management\include; ..\..\..\bsp\stm32\Libraries\CMSIS\Include; ..\..\..\bsp\stm32\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\bsp\stm32\Libraries\CMSIS\ST\STM32F0xx\Include; ..\..\..\bsp\stm32\include; ..\; ..\DSP; ..\..\..\include; ..\conf; ..\..\..\common\tym_qp_lib; ..\include
  group bsp
    ../../../bsp/gd32/: bsp.c
  group common
    ../../../common/controller/: controller.c
    ../../../common/crc16_lib/: crc16.c
    ../../../common/: persistantObj.c
    ../../../common/datatype/ringbuf/: ringbuf.c
    ../../../common/sort_lib/: sortLib.c
  group driver/adc_driver
    ../../../driver/adc_driver/gd32/: AdcDrv.c
  group driver/audio_driver
    ../portingLayer/AudioPorting/: AudioDrv.c
  group driver/bt_driver
    ../../../driver/bluetooth_driver/qcc300x/: BluetoothDrv.c
  group driver/dsp_amp
    ../DSP/: Adau1761_Drv.c
    ../../../driver/audio_driver/tas5760/: tas5760Drv.c
  group driver/gd32_driver/GD32F130_StdPeriph_Driver
    ../../../bsp/gd32/Libraries/GD32F35x_StdPeriph_Driver/src/: DAC.c stm32f0xx_adc.c stm32f0xx_crc.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_syscfg.c stm32f0xx_usart.c
  group driver/gd32_driver/startUpCode
    ../../../bsp/gd32/Libraries/CMSIS/GD/STM32F0xx/Source/: startup_stm32f0xx.s
  group driver/gpio_driver
    ../../../driver/gpio_driver/gd32/: GpioDrv.c
  group driver/i2c_driver
    ../../../driver/i2c_driver/gd32/: I2CDrv.c
  group driver/IoExpander_driver
    ../../../driver/ioexpander_driver/: IoExpanderDrv_9523.c
  group driver/key_driver
    ../../../driver/key_driver/: GpioKeyDrv.c KeyDrv.c LinearKnobKeyDrv.c
  group driver/led_driver
    ../portingLayer/LedDriver/: IoExpanderLedDrv.c LedDrv.c VIoExpanderGpioDrv.c
  group driver/power_driver
    ../portingLayer/PowerDrv/: PowerDrv_light.c
  group driver/storage_driver
    ../../../driver/storage_driver/gd32/: NvmDrv.c
    ../../../driver/storage_driver/: StorageDrv.c
  group driver/uart_driver
    ../../../driver/uart_driver/gd32/: UartDrv.c
  group hardware_management
    ../../../hardware_management/: deviceTypes.c
  group hendrix
    ../../../ui_layer/delegate/: delegate.c
    ../mainApp/idle_dlg/: IdleDlg.c IdleDlg_priv.h
    ../: main.c
  group hendrix/config
    ../conf/: AudioSrv.Config BluetoothDrv.config BluetoothSrv.Config controller.Config IdleDlg.config KeySrv.Config mainapp.config PowerDrv.config PowerDrv_light.config SettingSrv.config
    ../: product.config
    ../portingLayer/LedDriver/: VIoExpanderGpioDrv.config
  group hendrix/MainApp
    ../mainApp/: application.c application.h MainApp.c MainApp.h MainApp_batteryEvtHandler.c MainApp_batteryEvtHandler.h MainApp_bluetoothKeyEvtHandler.c MainApp_bluetoothKeyEvtHandler.h MainApp_keyEvtHandler.c MainApp_keyEvtHandler.h MainApp_priv.h MainApp_tickEvtHandler.c MainApp_tickEvtHandler.h MainApp_util.c MainApp_util.h
  group hendrix/stm32
    ../gd32/: attachedDevices.c projBsp.c
  group QP/qep
    ../../../common/qp/qep/source/: qep.c qep_pkg.h qfsm_dis.c qfsm_ini.c qhsm_dis.c qhsm_in.c qhsm_ini.c qhsm_top.c qmsm_dis.c qmsm_ini.c
  group QP/qf
    ../../../common/qp/qf/source/: qa_ctor.c qa_defer.c qa_fifo.c qa_get_.c qa_lifo.c qa_sub.c qa_usub.c qa_usuba.c qeq_fifo.c qeq_get.c qeq_init.c qeq_lifo.c qf_act.c qf_gc.c qf_log2.c qf_new.c qf_pkg.h qf_pool.c qf_psini.c qf_pspub.c qf_pwr2.c qf_tick.c qma_ctor.c qmp_get.c qmp_init.c qmp_put.c qte_arm.c qte_ctor.c qte_ctr.c qte_darm.c qte_rarm.c qvanilla.c
  group QP/qp_port
    ../../../common/qp/ports/stm32/: qep_port.h qf_port.h qs_port.h
  group QP/tym_qp_lib
    ../../../common/tym_qp_lib/: tym_qp_lib.c
  group server/audio_server
    ../../../server/audio_server/audioSrv_new/: AudioSrv.c
  group server/bt_server
    ../../../server/bt_server/bt_server_v2/: BluetoothSrv.c
  group server/debug_server
    ../../../server/ds_server/: DebugSSrv.c
  group server/key_server
    ../../../server/key_server/: KeySrv.c
  group server/led_server
    ../../../server/led_server/: LedSrv.c
  group server/Power_server
    ../../../server/power_server/powerSrv_new/: PowerSrv.c
  group server/setting_server
    ../../../server/setting_server/: SettingSrv.c

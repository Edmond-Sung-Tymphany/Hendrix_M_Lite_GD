# IAR project ubl.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F091RC ST STM32F091RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F0XX; USE_STDPERIPH_DRIVER; UART_DRV_BLOCKING; NDEBUG; _BOOTLOADER_UBL; BRINGUP_DEBUG
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\..\..\common\tym_qp_lib; ..\..\..\common\qp\include; ..\..\..\common\qp\ports\stm32; ..\..\..\common\include; ..\..\..\driver\include; ..\stm32\include; ..\..\..\hardware_management\include; ..\..\..\bsp\STM32\Libraries\CMSIS\Include; ..\..\..\bsp\STM32\Libraries\STM32F0xx_StdPeriph_Driver_v1.5\inc; ..\..\..\bsp\STM32\Libraries\CMSIS\ST\STM32F0xx\Include; ..\..\..\bsp\STM32\STM32F0-Discovery; ..\..\..\bsp\STM32\include; ..\; ..\..\..\include; ..\stm32\bootloader; ..\..\..\bootloaders\bl_stm32\inc; ..; ..\conf; ..\conf_common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Joplin_S_ubl.hex
  ILINK.IlinkOutputFile: Joplin_S_ubl.out
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkIcfFile: ubl.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F0XX; UART_DRV_BLOCKING; _BOOTLOADER_UBL
  ICCARM.CCIncludePath2: ..\..\..\common\tym_qp_lib; ..\..\..\common\qp\include; ..\..\..\common\qp\ports\stm32; ..\..\..\common\include; ..\..\..\driver\include; ..\stm32\include; ..\..\..\hardware_management\include; ..\..\..\bsp\STM32\Libraries\CMSIS\Include; ..\..\..\bsp\STM32\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\bsp\STM32\Libraries\CMSIS\ST\STM32F0xx\Include; ..\..\..\bsp\STM32\STM32F0-Discovery; ..\..\..\bsp\STM32\include; ..\; ..\..\..\include; ..\stm32\bootloader; ..\..\..\bootloaders\bl_stm32\inc; ..; ..\conf; ..\conf_common
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: BnO_fs1_mk2_ubl.hex
  ILINK.IlinkOutputFile: BnO_fs1_mk2_ubl.out
  group driver
    ../../../hardware_management/: deviceTypes.c
    ../../../driver/gpio_driver/stm32/: GpioDrv.c
  group driver/i2c
    ../../../driver/i2c_driver/stm32f0/: I2CDrv.c
  group driver/ioexpender
    ../../../driver/ioexpander_driver/: IoExpanderDrv_9523.c
  group driver/uart
    ../../../common/datatype/ringbuf/: ringbuf.c
    ../../../driver/uart_driver/stm32/: UartDrv.c
  group header
    ../stm32/include/: attachedDevices.h
    ../../../bootloaders/bl_stm32/inc/: bl_common.h ubl.h
    ../../../include/: commonTypes.h
    ../../../hardware_management/include/: deviceTypes.h
    ../: product.config
  group Joplin_S
    ../stm32/: attachedDevices.c
    ../stm32/bootloader/: ubl_cust.c
  group stm32xx
    ../../../bsp/stm32/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_crc.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_usart.c
  group ubl
    ../../../bootloaders/bl_stm32/: bl_bsp.c bl_common.c
    ../../../bootloaders/bl_stm32/ubl/: ubl.c

# IAR project SVS_PB16_Ultra.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F071CB ST STM32F071CB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\..\..\..\common\qp\include; ..\..\..\..\common\qp\ports\stm32; ..\..\..\..\driver\include; ..\..\stm32\include; ..\..\..\..\server\include; ..\..\..\..\ui_layer\include; ..\..\..\..\hardware_management\include; ..\..\..\..\bsp\stm32\Libraries\CMSIS\Include; ..\..\..\..\bsp\stm32\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\..\bsp\stm32\Libraries\CMSIS\ST\STM32F0xx\Include; ..\..\..\..\bsp\stm32\STM32F0-Discovery; ..\..\..\..\bsp\stm32\include; $PROJ_DIR$; ..\..\DSP\SVS_PB16; ..\..\..\..\include; ..\..\conf\SVS_PB; ..\..\..\..\common\tym_qp_lib; ..\..\conf
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SVS_PB16_Ultra.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: ..\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX; NDEBUG
  group bsp
    ../../../../bsp/stm32/: bsp.c
  group common
    ../../../../common/controller/: controller.c
    ../../../../common/crc16_lib/: crc16.c
    ../../../../common/: persistantObj.c
    ../../../../common/datatype/ringbuf/: ringbuf.c
    ../../../../common/sort_lib/: sortLib.c
  group driver/adc_driver
    ../../../../driver/adc_driver/stm32/: AdcDrv.c
  group driver/audio_driver
    ../../portingLayer/AudioPorting/: AudioDrv.c
  group driver/display_driver
    ../../../../driver/display_driver/tm1629_driver/: Tm1629Drv.c
  group driver/dsp_driver
    ../../portingLayer/adau1761_Drv/: dspAdau1761Drv.c
  group driver/gpio_driver
    ../../../../driver/gpio_driver/stm32/: GpioDrv.c
  group driver/i2c_driver
    ../../../../driver/i2c_driver/stm32f0/: I2CDrv.c
  group driver/include
    ../../../../driver/include/: AdcDrv.h AdcKeyDrv.h AudioDrv.h DisplayDrv.h DspAudioDrv.h DspDrv.h DspDrv_v1.h GpioDrv.h GpioKeyDrv.h hw_i2c_lib.h I2CDrv.h IRKeyDrv.h KeyDrv.h StorageDrv.h Tm1629Drv.h UartDrv.h
  group driver/Ir_receiver_driver
    ../../../../driver/ir_receiver_driver/NEC/: NecIrDrv.c
  group driver/key_driver
    ../../../../driver/key_driver/: AdcKeyDrv.c IRKeyDrv.c KeyDrv.c
  group driver/stm32_driver/startUpCode
    ../../../../bsp/stm32/Libraries/CMSIS/ST/STM32F0xx/Source/: startup_stm32f0xx.s
  group driver/stm32_driver/STM32F0xx_StdPeriph_Driver
    ../../../../bsp/stm32/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
  group driver/storage_driver
    ../../../../driver/storage_driver/stm32/: NvmDrv.c
    ../../../../driver/storage_driver/: StorageDrv.c
  group driver/uart_drvier
    ../../../../driver/uart_driver/stm32/: UartDrv.c
  group hardware_managerment
    ../../../../hardware_management/: deviceTypes.c
  group QP/qep
    ../../../../common/qp/qep/source/: qep.c qep_pkg.h qfsm_dis.c qfsm_ini.c qhsm_dis.c qhsm_in.c qhsm_ini.c qhsm_top.c qmsm_dis.c qmsm_ini.c
  group QP/qf
    ../../../../common/qp/qf/source/: qa_ctor.c qa_defer.c qa_fifo.c qa_get_.c qa_lifo.c qa_sub.c qa_usub.c qa_usuba.c qeq_fifo.c qeq_get.c qeq_init.c qeq_lifo.c qf_act.c qf_gc.c qf_log2.c qf_new.c qf_pkg.h qf_pool.c qf_psini.c qf_pspub.c qf_pwr2.c qf_tick.c qma_ctor.c qmp_get.c qmp_init.c qmp_put.c qte_arm.c qte_ctor.c qte_ctr.c qte_darm.c qte_rarm.c qvanilla.c
  group QP/qp_port
    ../../../../common/qp/ports/stm32/: qep_port.h qf_port.h qs_port.h
  group QP/tym_qp_lib
    ../../../../common/tym_qp_lib/: tym_qp_lib.c
  group server
    ../../../../server/: server.c
  group server/audio_server
    ../../../../server/audio_server/audioSrv_new/: AudioSrv.c
  group server/display_server
    ../../../../server/display_server/: DisplaySrv.c
  group server/ds_server
    ../../../../server/ds_server/: DebugSSrv.c
  group server/key_server
    ../../../../server/key_server/: KeySrv.c
  group server/setting_server
    ../../../../server/setting_server/: SettingSrv.c
  group server/timer
    ../../../../common/timer_lib/: timer.c
  group sub
    ../../: main.c MainApp.c
    ../../conf/SVS_PB/: product.config
  group sub/stm32
    ../../stm32/: attachedDevices.c projBsp.c
  group ui_layer/application
    ../../../../ui_layer/application/: application.c
  group ui_layer/delegate
    ../../../../ui_layer/delegate/: delegate.c
    ../../../../ui_layer/delegate/menu_dlg/: MenuDlg.c

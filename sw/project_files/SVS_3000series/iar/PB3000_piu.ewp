# IAR project PB3000_piu.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072CB ST STM32F072CB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F0XX; USE_STDPERIPH_DRIVER
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\..\..\common\tym_qp_lib; ..\..\..\common\qp\include; ..\..\..\common\qp\ports\stm32; ..\..\..\common\include; ..\..\..\driver\include; ..\stm32\include; ..\..\..\hardware_management\include; ..\..\..\bsp\STM32\Libraries\CMSIS\Include; ..\..\..\bsp\STM32\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\bsp\STM32\Libraries\CMSIS\ST\STM32F0xx\Include; ..\..\..\bsp\STM32\include; ..\..\..\server\include; ..\..\..\include; ..\piu; ..\conf\PB; ..\conf; ..\..\..\ui_layer\include; ..\..\..\driver\usb_driver\stm32f0\core\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PB3000_piu.hex
  ILINK.IlinkOutputFile: PB3000_piu.out
  ILINK.IlinkIcfFile: piu.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F0XX; UART_DRV_BLOCKING
  ICCARM.CCIncludePath2: ..\..\..\common\tym_qp_lib; ..\..\..\common\qp\include; ..\..\..\common\qp\ports\stm32; ..\..\..\common\include; ..\..\..\driver\include; ..\stm32\include; ..\..\..\hardware_management\include; ..\..\..\bsp\STM32\Libraries\CMSIS\Include; ..\..\..\bsp\STM32\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\bsp\STM32\Libraries\CMSIS\ST\STM32F0xx\Include; ..\..\..\bsp\STM32\include; ..\; ..\..\..\include; ..\stm32\bootloader; ..\..\..\bootloaders\bl_stm32\inc; ..; ..\conf; ..\conf\PB; ..\..\..\server\include; ..\..\..\ui_layer\include; ..\..\..\driver\usb_driver\stm32f0\core\inc
  ICCARM.CCOptLevel: 3
  group bsp
    ../../../bsp/stm32/: bsp.c
  group driver
    ../../../hardware_management/: deviceTypes.c
  group driver/gpio_driver
    ../../../driver/gpio_driver/stm32/: GpioDrv.c
  group driver/i2c_driver
    ../../../driver/i2c_driver/stm32f0/: I2CDrv.c
  group driver/led_driver
    ../../../driver/ioexpander_driver/: IoExpanderDrv_9523.c
  group driver/uart_driver
    ../../../driver/uart_driver/stm32/: UartDrv.c
  group piu
    ../piu/: piu.c piu_common.c
  group piu/stm32
    ../stm32/: attachedDevices.c projBsp.c
  group QP
    ../../../common/qp/qf/source/: qf_tick.c
  group stm32xx
    ../../../bsp/stm32/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_crc.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_usart.c

# IAR project SVS_SB3000.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072CB ST STM32F072CB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\..\..\common\tym_qp_lib; ..\..\..\common\qp\include; ..\..\..\common\qp\ports\stm32; ..\..\..\common\include; ..\..\..\driver\include; ..\stm32\include; ..\..\..\server\include; ..\..\..\hardware_management\include; ..\..\..\bsp\STM32\Libraries\CMSIS\Include; ..\..\..\bsp\STM32\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\bsp\STM32\Libraries\CMSIS\ST\STM32F0xx\Include; ..\..\..\bsp\STM32\include; ..\; ..\DSP; ..\..\..\include; ..\conf; ..\mainApp; ..\..\..\bootloaders\bl_stm32\inc; ..\DSP; ..\portingLayer\AudioPorting; ..\portingLayer\adau1761_Drv; ..\..\..\ui_layer\include; ..\dsp\SB; ..\conf\SB; ..\portingLayer\PowerPorting; ..\..\..\driver\usb_driver\stm32f0\core\inc; ..\..\..\driver\usb_driver\stm32f0\class\include; ..\piu; ..\..\..\common\tp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SVS_SB3000.hex
  ILINK.IlinkOutputFile: SVS_SB3000.out
  ILINK.IlinkIcfFile: svs3000.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX; NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\common\tym_qp_lib; ..\..\..\common\qp\include; ..\..\..\common\qp\ports\stm32; ..\..\..\common\include; ..\..\..\driver\include; ..\stm32\include; ..\..\..\server\include; ..\..\..\hardware_management\include; ..\..\..\bsp\STM32\Libraries\CMSIS\Include; ..\..\..\bsp\STM32\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\bsp\STM32\Libraries\CMSIS\ST\STM32F0xx\Include; ..\..\..\bsp\STM32\include; ..\; ..\DSP; ..\..\..\include; ..\conf; ..\mainApp; ..\mainApp; ..\..\..\bootloaders\bl_stm32\inc; ..\amp; ..\..\..\ui_layer\include; ..\DSP; ..\portingLayer\adau1761_Drv; ..\portingLayer\AudioPorting; ..\conf\SB; ..\dsp\SB; ..\..\..\driver\usb_driver\stm32f0\class\include; ..\..\..\driver\usb_driver\stm32f0\core\inc; ..\piu
  ICCARM.CCOptLevel: 3
  group bsp
    ../../../bsp/stm32/: bsp.c
  group common
    ../../../bootloaders/bl_stm32/: bl_common.c
    ../../../common/controller/: controller.c
    ../../../common/crc16_lib/: crc16.c
    ../../../common/: persistantObj.c seq.c
    ../../../common/datatype/ringbuf/: ringbuf.c
    ../../../common/sort_lib/: sortLib.c
    ../../../common/timer_lib/: timer.c
    ../../../common/tp/: tp_common.c
    ../../../common/tym_qp_lib/: tym_qp_lib.c
  group driver/adc_driver
    ../../../driver/adc_driver/stm32/: AdcDrv.c
  group driver/Audio_driver
    ../portingLayer/AudioPorting/: AudioDrv.c
  group driver/ble_driver
    ../../../driver/ble_driver/: BleDrv.c
  group driver/dsp_driver
    ../portingLayer/adau1761_Drv/: dspAdau1761Drv.c
  group driver/gpio_driver
    ../../../driver/gpio_driver/stm32/: GpioDrv.c
  group driver/i2c_driver
    ../../../driver/i2c_driver/stm32f0/: I2CDrv.c
  group driver/ioexpander_driver
    ../../../driver/ioexpander_driver/: IoExpanderDrv_9110b.c IoExpanderDrv_9120.c IoExpanderDrv_9523.c
  group driver/key_driver
    ../../../driver/key_driver/: AdcKeyDrv.c KeyDrv.c
  group driver/led_driver
    ../../../driver/led_driver/: IoExpanderLedDrv.c LedDrv.c
  group driver/power_driver
    ../portingLayer/PowerPorting/: PowerDrv_light.c
  group driver/stm32_driver/startUpCode
    ../../../bsp/stm32/Libraries/CMSIS/ST/STM32F0xx/Source/: startup_stm32f0xx.s
  group driver/stm32_driver/STM32F0xx_StdPeriph_Driver
    ../../../bsp/stm32/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_crs.c stm32f0xx_dbgmcu.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_syscfg.c stm32f0xx_usart.c
  group driver/storage_driver
    ../../../driver/storage_driver/stm32/: NvmDrv.c
    ../../../driver/storage_driver/: StorageDrv.c
  group driver/uart_drvier
    ../../../driver/uart_driver/stm32/: UartDrv.c
  group driver/usb_driver
    ../../../driver/usb_driver/stm32f0/: UsbDrv.c
  group driver/usb_driver/class
    ../../../driver/usb_driver/stm32f0/class/vcp/: usbd_cdc_core.c
  group driver/usb_driver/core
    ../../../driver/usb_driver/stm32f0/core/src/: usb_core.c usb_dcd.c usbd_pwr.c usbd_req.c
  group hardware_managerment
    ../../../hardware_management/: deviceTypes.c
  group QP/qep
    ../../../common/qp/qep/source/: qep.c qep_pkg.h qfsm_dis.c qfsm_ini.c qhsm_dis.c qhsm_in.c qhsm_ini.c qhsm_top.c qmsm_dis.c qmsm_ini.c
  group QP/qf
    ../../../common/qp/qf/source/: qa_ctor.c qa_defer.c qa_fifo.c qa_get_.c qa_lifo.c qa_sub.c qa_usub.c qa_usuba.c qeq_fifo.c qeq_get.c qeq_init.c qeq_lifo.c qf_act.c qf_gc.c qf_log2.c qf_new.c qf_pkg.h qf_pool.c qf_psini.c qf_pspub.c qf_pwr2.c qf_tick.c qma_ctor.c qmp_get.c qmp_init.c qmp_put.c qte_arm.c qte_ctor.c qte_ctr.c qte_darm.c qte_rarm.c qvanilla.c
  group QP/qp_port
    ../../../common/qp/ports/stm32/: qep_port.h qf_port.h qs_port.h
  group server
    ../../../server/: server.c
  group server/audio_server
    ../../../server/audio_server/audioSrv_new/: AudioSrv.c
  group server/ble_server
    ../../../server/ble_server/: BleSrv.c
  group server/debug_server
    ../../../server/ds_server/: DebugSSrv.c
  group server/key_server
    ../../../server/key_server/: KeySrv.c
  group server/led_server
    ../../../server/led_server/: LedSrv.c
  group server/power_server
    ../../../server/power_server/powerSrv_new/: PowerSrv.c
  group server/setting_server
    ../../../server/setting_server/: SettingSrv.c
  group server/usb_server
    ../../../server/usb_server/: UsbSrv.c
  group svs/mainApp
    ../mainApp/: MainApp.c MainApp_bleEvtHandler.c MainApp_keyEvtHandler.c MainApp_keyEvtHandler.h MainApp_tickEvtHandler.c MainApp_tickEvtHandler.h MainApp_util.c MainApp_util.h
  group svs/piu
    ../piu/: piu_common.c
  group svs/stm32
    ../stm32/: attachedDevices.c projBsp.c
  group ui_layer/main
    ../mainApp/: main.c

<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SVS_SB3000.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SB3000_piu.ewp</path>
  </project>
  <batchBuild/>
</workspace>



# IAR project BnO_fs2.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F091RC ST STM32F091RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX; BnO_fs2
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\..\..\common\tym_qp_lib; ..\..\..\common\qp\include; ..\..\..\common\qp\ports\stm32; ..\..\..\common\include; ..\..\..\driver\include; ..\..\..\project_files\BnO_fs2\stm32\include; ..\..\..\server\include; ..\..\..\hardware_management\include; ..\..\..\bsp\STM32\Libraries\CMSIS\Include; ..\..\..\bsp\STM32\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\bsp\STM32\Libraries\CMSIS\ST\STM32F0xx\Include; ..\..\..\bsp\STM32\STM32F0-Discovery; ..\..\..\bsp\STM32\include; ..\..\..\project_files\BnO_fs2\; ..\..\..\include; ..\..\..\project_files\BnO_fs2\conf; ..\..\..\server\ase_tk_server\message_format; ..\..\..\project_files\BnO_fs2\audio_ADC; ..\..\..\bootloaders\bl_stm32\inc; ..\..\..\ui_layer\BnO_MainApp\inc; ..\..\..\ui_layer\BnO_MainApp\src; ..\..\..\project_files\BnO_fs2\DSP\; ..\..\..\project_files\BnO_fs2\amp; ..\..\..\driver\key_driver\AzIntegTouchKeyDrv\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BnO_fs2.hex
  ILINK.IlinkOutputFile: BnO_fs2.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F0XX; Q_NASSERT; BnO_fs2
  ICCARM.CCOptLevel: 3
  group BnO_fs2/mainApp
    ../../BnO_fs2/mainApp/: MainApp.c
  group BnO_fs2/stm32
    ../../BnO_fs2/stm32/: attachedDevices.c projBsp.c
  group bsp
    ../../../bsp/stm32/: bsp.c
  group common
    ../../../bootloaders/bl_stm32/: bl_common.c
    ../../../common/controller/: controller.c
    ../../../common/crc16_lib/: crc16.c
    ../../../common/: persistantObj.c seq.c
    ../../../common/datatype/ringbuf/: ringbuf.c
    ../../../common/sort_lib/: sortLib.c
    ../../../common/tym_qp_lib/: tym_qp_lib.c
  group config
    ../conf/: AudioDrv.config AudioSrv.Config controller.Config IoExpanderDrv.config KeySrv.Config LedSrv.Config MainApp.Config pattern.h PowerDrv_light.config SettingSrv.config
    ../: product.config
  group driver/adc_driver
    ../../../driver/adc_driver/stm32/: AdcDrv.c
  group driver/Audio_driver
    ../../BnO_fs2/portingLayer/AudioPorting/: AudioDrv.c
    ../../../driver/audio_driver/pcm1862_v2/: pcm1862Drv.c
    ../../../driver/audio_driver/tas5760/: tas5760Drv.c
  group driver/dsp_driver
    ../DSP/: adau1451_config.h
    ../../../driver/DSP_Driver/adau1451_drv/: dspAdau1451Drv.c dspAdau1451Drv_priv.h
  group driver/gpio_driver
    ../../../driver/gpio_driver/stm32/: GpioDrv.c
  group driver/i2c_driver
    ../../../driver/i2c_driver/stm32f0/: I2CDrv.c
  group driver/ioexpander_driver
    ../../../driver/ioexpander_driver/aw9110b/: IoExpanderDrv.c
  group driver/key_driver
    ../../../driver/key_driver/: AdcKeyDrv.c GpioKeyDrv.c KeyDrv.c RotaterKeyDrv.c
  group driver/key_driver/AzIntegTouchKeyDrv
    ../../../driver/key_driver/: AzIntegTouchKeyDrv.c
  group driver/key_driver/AzIntegTouchKeyDrv/inc
    ../../../driver/key_driver/AzIntegTouchKeyDrv/inc/: Defines.h Gestures.h I2C_Comms.h IQS333.h IQS333_Init.h IQS5xx.h IQS5xx_HEX_Array.h IQS_Commands.h State_Machine.h
  group driver/key_driver/AzIntegTouchKeyDrv/src
    ../../../driver/key_driver/AzIntegTouchKeyDrv/src/: Gestures.c I2C_Comms.c IQS333.c IQS5xx.c IQS_Commands.c State_Machine.c
  group driver/led_driver
    ../../../driver/led_driver/: IoExpanderLedDrv.c LedDrv.c
  group driver/power_driver
    ../../BnO_fs2/portingLayer/PowerPorting/: PowerDrv_light.c
  group driver/stm32_driver/startUpCode
    ../../../bsp/stm32/Libraries/CMSIS/ST/STM32F0xx/Source/: startup_stm32f0xx.s
  group driver/stm32_driver/STM32F0xx_StdPeriph_Driver
    ../../../bsp/stm32/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_usart.c
  group driver/storage_driver
    ../../../driver/storage_driver/stm32/: NvmDrv.c
    ../../../driver/storage_driver/: StorageDrv.c
  group driver/uart_drvier
    ../../../common/framing/yahdlc/C/: fcs16.c yahdlc.c
    ../../../common/nanopb/: pb_common.c pb_decode.c pb_encode.c
    ../../../driver/uart_driver/stm32/: UartDrv.c
  group hardware_managerment
    ../../../hardware_management/: deviceTypes.c
  group QP/qep
    ../../../common/qp/qep/source/: qep.c qep_pkg.h qfsm_dis.c qfsm_ini.c qhsm_dis.c qhsm_in.c qhsm_ini.c qhsm_top.c qmsm_dis.c qmsm_ini.c
  group QP/qf
    ../../../common/qp/qf/source/: qa_ctor.c qa_defer.c qa_fifo.c qa_get_.c qa_lifo.c qa_sub.c qa_usub.c qa_usuba.c qeq_fifo.c qeq_get.c qeq_init.c qeq_lifo.c qf_act.c qf_gc.c qf_log2.c qf_new.c qf_pkg.h qf_pool.c qf_psini.c qf_pspub.c qf_pwr2.c qf_tick.c qma_ctor.c qmp_get.c qmp_init.c qmp_put.c qte_arm.c qte_ctor.c qte_ctr.c qte_darm.c qte_rarm.c qvanilla.c
  group QP/qp_port
    ../../../common/qp/ports/stm32/: qep_port.h qf_port.h qs_port.h
  group server
    ../../../server/: server.c
  group server/asetk_server
    ../../../server/ase_tk_server/: AseTkSrv.c
    ../../../server/ase_tk_server/beo_ase_fep_proto/: beo_ase_fep.pb.c
    ../../../common/Error_handle_lib/: errorHandleLib.c
  group server/audio_server
    ../../../server/audio_server/audioSrv_new/: AudioSrv.c
  group server/debug_server
    ../../../server/ds_server/: DebugSSrv.c
  group server/key_server
    ../../../server/key_server/: KeySrv.c
  group server/led_server
    ../../../server/led_server/: LedSrv.c
  group server/power_server
    ../../../server/power_server/: PowerSrv.c
  group server/setting_server
    ../../../server/setting_server/: SettingSrv.c
  group ui_layer/application
    ../../../ui_layer/application/: application.c
  group ui_layer/BnO_MainApp
    ../../../ui_layer/BnO_MainApp/src/: BnO_MainApp.c BnO_MainApp_aseTkEvtHandler.c BnO_MainApp_aseTkEvtHandler.h BnO_MainApp_keyEvtHandler.c BnO_MainApp_keyEvtHandler.h BnO_MainApp_priv.h BnO_MainApp_tickEvtHandler.c BnO_MainApp_tickEvtHandler.h BnO_MainApp_util.c BnO_MainApp_util.h main.c
  group ui_layer/delegate
    ../../../ui_layer/delegate/: delegate.c
  group ui_layer/delegate/idle_dlg
    ../../../ui_layer/delegate/idle_dlg/: IdleDlg.c

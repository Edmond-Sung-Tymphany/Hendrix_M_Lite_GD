# IAR project iBT150.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x8 ST STM32F030x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX; IBT150; NO_DSP_I2S_INPUT; AUDIO_MULTI_SOURCE; USE_DEBUG_SETTING_SERVER
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\..\..\common\tym_qp_lib; ..\..\..\common\qp\include; ..\..\..\common\qp\ports\stm32; ..\..\..\common\include; ..\..\..\driver\include; ..\stm32\include; ..\..\..\server\include; ..\..\..\ui_layer\include; ..\..\..\hardware_management\include; ..\..\..\bsp\stm32\Libraries\CMSIS\Include; ..\..\..\bsp\stm32\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\bsp\stm32\Libraries\CMSIS\ST\STM32F0xx\Include; ..\..\..\bsp\stm32\STM32F0-Discovery; ..\..\..\bsp\stm32\include; ..\; ..\DSP; ..\..\..\include; ..\conf
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: iBT150.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F0XX; IBT150; NO_DSP_I2S_INPUT; AUDIO_MULTI_SOURCE
  ICCARM.CCOptStrategy: 1
  group bsp
    ../../../bsp/stm32/: bsp.c
  group common
    ../../../common/controller/: controller.c
    ../../../common/crc16_lib/: crc16.c
    ../../../common/: persistantObj.c
    ../../../common/datatype/ringbuf/: ringbuf.c
    ../../../common/sort_lib/: sortLib.c
    ../../../common/tym_qp_lib/: tym_qp_lib.c
  group driver/adc_driver
    ../../../driver/adc_driver/stm32/: AdcDrv.c
  group driver/Audio_driver
    ../../../driver/audio_driver/stm32/: AudioDrv.c
  group driver/bt_driver
    ../../../driver/bluetooth_driver/rom_base/: BluetoothDrv.c
  group driver/dsp_driver
    ../../../driver/DSP_Driver/TLV320AIC3254_drv/: DspDrv.c
  group driver/gpio_driver
    ../../../driver/gpio_driver/stm32/: GpioDrv.c
  group driver/i2c_driver
    ../../../driver/i2c_driver/stm32/: I2CDrv.c
  group driver/ioexpander_driver
    ../../../driver/ioexpander_driver/: IoExpanderDrv.c
  group driver/key_driver
    ../../../driver/key_driver/: AdcKeyDrv.c GpioKeyDrv.c KeyDrv.c
  group driver/led_driver
    ../../../driver/led_driver/: IoExpanderLedDrv.c LedDrv.c
  group driver/power_driver
    ../../../driver/power_driver/stm32/: PowerDrv.c
  group driver/stm32_driver/startUpCode
    ../../../bsp/stm32/Libraries/CMSIS/ST/STM32F0xx/Source/: startup_stm32f0xx.s
  group driver/stm32_driver/STM32F0xx_StdPeriph_Driver
    ../../../bsp/stm32/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
  group driver/storage_driver
    ../../../driver/storage_driver/stm32/: NvmDrv.c
    ../../../driver/storage_driver/: StorageDrv.c
  group driver/uart_drvier
    ../../../driver/uart_driver/stm32/: UartDrv.c
  group hardware_managerment
    ../../../hardware_management/: deviceTypes.c
  group iBT150
    ../: main.c MainApp.c
  group iBT150/stm32
    ../stm32/: attachedDevices.c projBsp.c
  group QP/qep
    ../../../common/qp/qep/source/: qep.c qep_pkg.h qfsm_dis.c qfsm_ini.c qhsm_dis.c qhsm_in.c qhsm_ini.c qhsm_top.c qmsm_dis.c qmsm_ini.c
  group QP/qf
    ../../../common/qp/qf/source/: qa_ctor.c qa_defer.c qa_fifo.c qa_get_.c qa_lifo.c qa_sub.c qa_usub.c qa_usuba.c qeq_fifo.c qeq_get.c qeq_init.c qeq_lifo.c qf_act.c qf_gc.c qf_log2.c qf_new.c qf_pkg.h qf_pool.c qf_psini.c qf_pspub.c qf_pwr2.c qf_tick.c qma_ctor.c qmp_get.c qmp_init.c qmp_put.c qte_arm.c qte_ctor.c qte_ctr.c qte_darm.c qte_rarm.c qvanilla.c
  group QP/qp_port
    ../../../common/qp/ports/stm32/: qep_port.h qf_port.h qs_port.h
  group server
    ../../../server/: server.c
  group server/audio_server
    ../../../server/audio_server/: AudioSrv.c
  group server/bt_server
    ../../../server/bt_server/: BluetoothSrv.c
  group server/dss_server
    ../../../server/dss_server/: DebugSettSrv.c
  group server/key_server
    ../../../server/key_server/: KeySrv.c
  group server/led_server
    ../../../server/led_server/: LedSrv.c
  group server/power_server
    ../../../server/power_server/: PowerSrv.c
  group ui_layer/application
    ../../../ui_layer/application/: application.c
  group ui_layer/delegate
    ../../../ui_layer/delegate/bluetooth_dlg/: BluetoothDlg.c
    ../../../ui_layer/delegate/: delegate.c
    ../../../ui_layer/delegate/power_dlg/: PowerDlg.c

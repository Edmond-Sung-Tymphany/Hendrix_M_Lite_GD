<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>bsp</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\bsp\stm32\bsp.c</name>
    </file>
  </group>
  <group>
    <name>common</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\common\controller\controller.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\common\crc16_lib\crc16.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\common\persistantObj.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\common\datatype\ringbuf\ringbuf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\common\sort_lib\sortLib.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\common\tym_qp_lib\tym_qp_lib.c</name>
    </file>
  </group>
  <group>
    <name>driver</name>
    <group>
      <name>adc_driver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\driver\adc_driver\stm32\AdcDrv.c</name>
      </file>
    </group>
    <group>
      <name>Audio_driver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\driver\audio_driver\stm32\AudioDrv.c</name>
      </file>
    </group>
    <group>
      <name>bt_driver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\driver\bluetooth_driver\rom_base\BluetoothDrv.c</name>
      </file>
    </group>
    <group>
      <name>dsp_driver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\driver\DSP_Driver\TLV320AIC3254_drv\DspDrv.c</name>
      </file>
    </group>
    <group>
      <name>gpio_driver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\driver\gpio_driver\stm32\GpioDrv.c</name>
      </file>
    </group>
    <group>
      <name>i2c_driver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\driver\i2c_driver\stm32\I2CDrv.c</name>
      </file>
    </group>
    <group>
      <name>key_driver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\driver\key_driver\AdcKeyDrv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\driver\key_driver\GpioKeyDrv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\driver\key_driver\KeyDrv.c</name>
      </file>
    </group>
    <group>
      <name>power_driver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\driver\power_driver\stm32\PowerDrv_light.c</name>
      </file>
    </group>
    <group>
      <name>stm32_driver</name>
      <group>
        <name>startUpCode</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\Libraries\CMSIS\ST\STM32F0xx\Source\startup_stm32f0xx.s</name>
        </file>
      </group>
      <group>
        <name>STM32F0xx_StdPeriph_Driver</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_adc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_exti.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_i2c.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_misc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_pwr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_rcc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_syscfg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_usart.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>uart_drvier</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\driver\uart_driver\stm32\UartDrv.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>hardware_managerment</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\hardware_management\deviceTypes.c</name>
    </file>
  </group>
  <group>
    <name>mc-13</name>
    <group>
      <name>stm32</name>
      <file>
        <name>$PROJ_DIR$\..\stm32\attachedDevices.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\stm32\projBsp.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\MainApp.c</name>
    </file>
  </group>
  <group>
    <name>QP</name>
    <group>
      <name>qep</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qep\source\qep.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qep\source\qep_pkg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qep\source\qfsm_dis.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qep\source\qfsm_ini.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qep\source\qhsm_dis.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qep\source\qhsm_in.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qep\source\qhsm_ini.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qep\source\qhsm_top.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qep\source\qmsm_dis.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qep\source\qmsm_ini.c</name>
      </file>
    </group>
    <group>
      <name>qf</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qa_ctor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qa_defer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qa_fifo.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qa_get_.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qa_lifo.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qa_sub.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qa_usub.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qa_usuba.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qeq_fifo.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qeq_get.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qeq_init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qeq_lifo.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qf_act.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qf_gc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qf_log2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qf_new.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qf_pkg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qf_pool.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qf_psini.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qf_pspub.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qf_pwr2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qf_tick.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qma_ctor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qmp_get.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qmp_init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qmp_put.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qte_arm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qte_ctor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qte_ctr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qte_darm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qte_rarm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\qf\source\qvanilla.c</name>
      </file>
    </group>
    <group>
      <name>qp_port</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\ports\stm32\qep_port.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\ports\stm32\qf_port.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\common\qp\ports\stm32\qs_port.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>server</name>
    <group>
      <name>audio_server</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\server\audio_server\AudioSrv.c</name>
      </file>
    </group>
    <group>
      <name>bt_server</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\server\bt_server\BluetoothSrv.c</name>
      </file>
    </group>
    <group>
      <name>debug_server</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\server\ds_server\DebugSSrv.c</name>
      </file>
    </group>
    <group>
      <name>key_server</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\server\key_server\KeySrv.c</name>
      </file>
    </group>
    <group>
      <name>setting_server</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\server\setting_server\SettingSrv.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\server\server.c</name>
    </file>
  </group>
  <group>
    <name>ui_layer</name>
    <group>
      <name>application</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\ui_layer\application\application.c</name>
      </file>
    </group>
  </group>
</project>



# IAR project stanmore.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x8 ST STM32F030x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX; Q_NASSERT; STANMORE; HAS_I2S_INPUT
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\..\..\common\tym_qp_lib; ..\..\..\common\qp\include; ..\..\..\common\qp\ports\stm32; ..\..\..\common\include; ..\..\..\driver\include; ..\stm32\include; ..\..\..\server\include; ..\..\..\ui_layer\include; ..\..\..\hardware_management\include; ..\..\..\bsp\STM32\Libraries\CMSIS\Include; ..\..\..\bsp\STM32\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\bsp\STM32\Libraries\CMSIS\ST\STM32F0xx\Include; ..\..\..\bsp\STM32\STM32F0-Discovery; ..\..\..\bsp\STM32\include; ..\; ..\DSP; ..\..\..\include; ..\conf; ..\audio_ADC
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stanmore.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F0XX; Q_NASSERT; STANMORE; HAS_I2S_INPUT
  group bsp
    ../../../bsp/stm32/: bsp.c
  group common
    ../../../common/controller/: controller.c
    ../../../common/crc16_lib/: crc16.c
    ../../../common/: persistantObj.c
    ../../../common/datatype/ringbuf/: ringbuf.c
    ../../../common/sort_lib/: sortLib.c
    ../../../common/tym_qp_lib/: tym_qp_lib.c
  group driver/adc_driver
    ../../../driver/adc_driver/stm32/: AdcDrv.c
  group driver/Audio_driver
    ../../../driver/audio_driver/stm32/: AudioDrv.c
    ../../../driver/audio_driver/pcm1862/: pcm1862Drv.c
  group driver/bt_driver
    ../../../driver/bluetooth_driver/rom_base/: BluetoothDrv.c
  group driver/dsp_driver
    ../../../driver/DSP_Driver/TAS5711/: DspTAS5711Drv.c
  group driver/gpio_driver
    ../../../driver/gpio_driver/stm32/: GpioDrv.c
  group driver/i2c_driver
    ../../../driver/i2c_driver/stm32f0/: I2CDrv.c
  group driver/key_driver
    ../../../driver/key_driver/: GpioKeyDrv.c KeyDrv.c LinearKnobKeyDrv.c
  group driver/power_driver
    ../../../driver/power_driver/stm32/: PowerDrv_light.c
  group driver/stm32_driver/startUpCode
    ../../../bsp/stm32/Libraries/CMSIS/ST/STM32F0xx/Source/: startup_stm32f0xx.s
  group driver/stm32_driver/STM32F0xx_StdPeriph_Driver
    ../../../bsp/stm32/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_usart.c
  group driver/storage_driver
    ../../../driver/storage_driver/stm32/: NvmDrv.c
    ../../../driver/storage_driver/: StorageDrv.c
  group driver/uart_drvier
    ../../../driver/uart_driver/stm32/: UartDrv.c
  group hardware_managerment
    ../../../hardware_management/: deviceTypes.c
  group QP/qep
    ../../../common/qp/qep/source/: qep.c qep_pkg.h qfsm_dis.c qfsm_ini.c qhsm_dis.c qhsm_in.c qhsm_ini.c qhsm_top.c qmsm_dis.c qmsm_ini.c
  group QP/qf
    ../../../common/qp/qf/source/: qa_ctor.c qa_defer.c qa_fifo.c qa_get_.c qa_lifo.c qa_sub.c qa_usub.c qa_usuba.c qeq_fifo.c qeq_get.c qeq_init.c qeq_lifo.c qf_act.c qf_gc.c qf_log2.c qf_new.c qf_pkg.h qf_pool.c qf_psini.c qf_pspub.c qf_pwr2.c qf_tick.c qma_ctor.c qmp_get.c qmp_init.c qmp_put.c qte_arm.c qte_ctor.c qte_ctr.c qte_darm.c qte_rarm.c qvanilla.c
  group QP/qp_port
    ../../../common/qp/ports/stm32/: qep_port.h qf_port.h qs_port.h
  group server
    ../../../server/: server.c
  group server/audio_server
    ../../../server/audio_server/: AudioSrv.c
  group server/bt_server
    ../../../server/bt_server/: BluetoothSrv.c
  group server/debug_server
    ../../../server/ds_server/: DebugSSrv.c
  group server/key_server
    ../../../server/key_server/: KeySrv.c
  group server/setting_server
    ../../../server/setting_server/: SettingSrv.c
  group stanmore
    ../: main.c MainApp.c
  group stanmore/stm32
    ../stm32/: attachedDevices.c projBsp.c
  group ui_layer/application
    ../../../ui_layer/application/: application.c
